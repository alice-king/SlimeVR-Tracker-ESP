## sdkconfig.defaults.esp8266
```kconfig
CONFIG_ESPTOOLPY_FLASHMODE_DIO=y
CONFIG_ESPTOOLPY_FLASHMODE="dio"
CONFIG_ESP8266_XTAL_FREQ_40=y
CONFIG_ESP8266_XTAL_FREQ=40
```
